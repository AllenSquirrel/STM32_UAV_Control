# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STDDRIVER\INC;..\HARDWARE\beep_pwm;..\HARDWARE\key
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group mdk
    ./: startup_stm32f10x_hd.s
  group stddriver
    ../STDDRIVER/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group user
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group hardware
    ../HARDWARE/key/: key.c
    ../HARDWARE/beep_pwm/: pwm.c
